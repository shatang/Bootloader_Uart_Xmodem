# Keil uVision project Bootloader_Xmodem.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Shatang +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\Board_Supports_Package\Buzzer;..\Board_Supports_Package\Timer;..\Board_Supports_Package\Uart2;..\Board_Supports_Package\Uart4;..\Board_Supports_Package\InternalFlash;..\Xmodem
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_tim.c
  group BSP
    ../Board_Supports_Package/Timer/: Timer_Driver.c
    ../Board_Supports_Package/Uart2/: Rs232_Uart2_Driver.c
    ../Board_Supports_Package/Uart4/: Rs485_Uart4_Driver.c
  group Xmodem
    ../Xmodem/: common.c download.c flash_if.c xmodem.c crc16.c
  group README
    ../: readme.txt
